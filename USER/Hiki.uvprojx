# Keil uVision project Hiki.uvprojx, settings and files
target Hiki (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hiki +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\KEY;..\SYSTEM\usart;..\HARDWARE\LED;..\MALLOC;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\W25X16;..\USER;..\HARDWARE\LCD;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\OS;..\MALLOC;..\HARDWARE\ADC;..\EMWIN\Demo;..\DSP;..\EMWIN\EMWIN_WIN;..\HARDWARE\SERVO
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/KEY/: KEY.c
    ../HARDWARE/W25X16/: W25X16.c SPI1.c
    ../HARDWARE/LCD/: LCD_X.c
    ../HARDWARE/SERVO/: SERVO.c
    ../HARDWARE/ADC/: ADC.c TENSOR.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_crc.c stm32f10x_dma.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group EMWIN_CONFIG
    ../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h GUIConf.c
    ../EMWIN/STemWin/OS/: GUI_X.c
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin526_CM3_Keil.lib
  group DSP
    ../DSP/: MyDSP.c cr4_fft_256_stm32.s
